<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\2_register_led.ewp</path>
    </project>
    <batchBuild />
</workspace>
