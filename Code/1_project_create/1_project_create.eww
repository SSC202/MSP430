<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\1_project_create.ewp</path>
    </project>
    <batchBuild />
</workspace>
